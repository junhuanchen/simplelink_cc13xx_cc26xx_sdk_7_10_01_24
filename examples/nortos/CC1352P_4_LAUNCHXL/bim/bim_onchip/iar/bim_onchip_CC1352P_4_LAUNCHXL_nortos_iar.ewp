# IAR project bim_onchip_CC1352P_4_LAUNCHXL_nortos_iar.ewp, settings and files
configuration Debug_unsecure (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
configuration Release_unsecure (ARM)
  as the first configuration, except:
configuration Release (ARM)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ble5stack/rom/ble_rom_releases/cc26x2_v2_pg2/Final_Release/ble_rom.symbols
configuration Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: as above
configuration Dual_image (ARM)
  as the first configuration, except:
  ILINK.IlinkExtraOptions: as above
  group (top)
    ./: bim_onchip_CC1352P_4_LAUNCHXL_nortos_iar.ipcf
  group BIM Onchip
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/cc26xx/sha2/: sha2_driverlib.c sha2_driverlib.h
    $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/common/cc26xx/ecc/: sign_util.c sign_util.h
